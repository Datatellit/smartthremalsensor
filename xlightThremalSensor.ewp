# IAR project xlightThremalSensor.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD; RAM_EXECUTION; RF24
  ICCSTM8.CCIncludePath2: Project\inc; ..\xlightCommon\stm8l\STM8L15x_StdPeriph_Driver\inc; ..\xlightCommon\stm8l\Xlight-stm8l; ..\xlightCommon\stm8l\Xlight-stm8l\commonbusiness; ..\xlightCommon\xlightdefine; ..\xlightCommon\xlightdefine\Business
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: thremalsensor_v3.1.hex
  ILINK.IlinkOutputFile: xlightThremalSensor.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: ThremalSensor.bin
  group Common
    ../xlightCommon/stm8l/Xlight-stm8l/: common.c common.h delay.c delay.h rf24l01.c rf24l01.h stm8l15x_conf.h stm8l15x_it.h UsartDev.c UsartDev.h
  group Common/ComBusiness
    ../xlightCommon/xlightdefine/Business/: ProtocolBus.c ProtocolBus.h
    ../xlightCommon/stm8l/Xlight-stm8l/commonbusiness/: XlightComBus.c XlightComBus.h
  group Define
    ../xlightCommon/xlightdefine/: debugDefine.h MyMessage.h publicDefine.h xliNodeConfig.h
  group STM8L Library/inc
    ../xlightCommon/stm8l/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_clk.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_tim4.h stm8l15x_usart.h stm8l15x_wwdg.h
  group STM8L Library/src
    ../xlightCommon/stm8l/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_tim4.c stm8l15x_usart.c stm8l15x_wwdg.c
  group User/inc
    Project/inc/: _global.h ADC1Dev.h led.h ProtocolParser.h timer4.h
  group User/src
    Project/src/: ADC1Dev.c led.c main.c ProtocolParser.c stm8l15x_it.c timer4.c
